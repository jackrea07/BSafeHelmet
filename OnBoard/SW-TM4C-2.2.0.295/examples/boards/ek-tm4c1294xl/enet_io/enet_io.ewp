# IAR project enet_io.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_io.bin
  ILINK.IlinkOutputFile: enet_io.out
  ILINK.IlinkIcfFile: enet_io.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: cgifuncs.c enet_io.c io.c io_fs.c startup_ewarm.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
    ../drivers/: pinout.c
