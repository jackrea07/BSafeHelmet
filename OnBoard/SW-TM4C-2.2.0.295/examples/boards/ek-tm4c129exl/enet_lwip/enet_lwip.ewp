# IAR project enet_lwip.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2; EK_TM4C129_BP1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_lwip.bin
  ILINK.IlinkOutputFile: enet_lwip.out
  ILINK.IlinkIcfFile: enet_lwip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: enet_fs.c enet_lwip.c startup_ewarm.c
    ../../../../third_party/fatfs/src/: ff.c
    ../../../../third_party/lwip-1.4.1/apps/httpserver_raw/: httpd.c
    ../../../../utils/: locator.c lwiplib.c uartstdio.c ustdlib.c
    ../../../../third_party/fatfs/port/: mmc-ek-tm4c1294xl.c
    ../drivers/: pinout.c
