# IAR project enet_uip.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2; DEBUG_OUTPUT; UIP_OFFLOAD_ICMP_CHKSUM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..; ..\..\..\..; ..\..\..\..\third_party\uip-1.0\apps; ..\..\..\..\third_party\uip-1.0\uip; ..\..\..\..\third_party\uip-1.0; ..\..\..\..\utils
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: enet_uip.bin
  ILINK.IlinkOutputFile: enet_uip.out
  ILINK.IlinkIcfFile: enet_uip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../../../../third_party/uip-1.0/apps/dhcpc/: dhcpc.c
    ./: enet_uip.c startup_ewarm.c
    ../../../../third_party/uip-1.0/apps/httpd/: httpd.c
    ../drivers/: pinout.c
    ../../../../utils/: uartstdio.c ustdlib.c
    ../../../../third_party/uip-1.0/uip/: uip.c uip_arp.c uip_timer.c
