# IAR project uart_echo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: uart_echo.bin
  ILINK.IlinkOutputFile: uart_echo.out
  ILINK.IlinkIcfFile: uart_echo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: startup_ewarm.c uart_echo.c
