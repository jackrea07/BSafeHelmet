# IAR project sha1_hmac.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: TM4C129ENCPDT TexasInstruments TM4C129ENCPDT
  ICCARM.CCDefines: ewarm; PART_TM4C129ENCPDT; TARGET_IS_TM4C129_RA2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: sha1_hmac.bin
  ILINK.IlinkOutputFile: sha1_hmac.out
  ILINK.IlinkIcfFile: sha1_hmac.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ../drivers/: pinout.c
    ./: sha1_hmac.c startup_ewarm.c
    ../../../../utils/: uartstdio.c
